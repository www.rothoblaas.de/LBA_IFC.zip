Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 573a5f2a-3657-4229-976a-7bcbb49b65ef, NumberOfSaves: 66], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Screw_LBA_460.ifc
Time: 2025-10-31T11:39:10
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcMechanicalFastener: Collegamenti strutturali : ROTHOB_Rothoblaas_Screw_LBA : LBA460_4x60mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Screw_LBA; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23.20.40.11.14.17; OmniClassTitle: Nails; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/screws/screws-carpentry/lba; Revision: 000; UniClass2015Code: Pr_20_29_56_11; UniClass2015Title: Carbon steel nails; UniClass2015Version: Products v1.39; Version: 001
Type - Vincoli - ModelNumberCode: 460; Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized
Type - Quote - ExternalDiameter_de: 4.4 mm; HeadDiameter_dk: 8 mm; HeadThickness_t1: 1.5 mm; HoleDiameterOnSteelPlate_dvs: 5.00 ÷5.5 mm; InsertionLength_L: 58.5 mm; KnurledShanksLength_b: 50 mm; KnurledShanksRadius: 1.7 mm; NominalDiameter_d1: 4 mm; ShankLength_Ls: 6.9 mm; ThreadDiameter_d2: 3.4 mm; TipLength_Lt: 3.86 mm; UnderheadDiameter_d3: 5.9 mm; UnderheadLength_L1: 1.6 mm
Type - Dati identità - Descrizione: High bond nail; Nome del tipo: LBA460_4x60mm; Numero OmniClass: 23.20.40.11.14.17; Produttore: info@rothoblaas.com; Titolo OmniClass: Nails
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_29_56_11 : Carbon steel nails; CECode: ETA-22/0002; CETitle: Rotho Blaas Connector Nails LBA; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: High bond nail; DurationUnit: Years; ExpectedLife: 50; Features: Adhesion nails with knurled shanks for timber constructions; Finish: Electrogalvanized; Grade: n/a; GTIN: 8033224488776; Manufacturer: info@rothoblaas.com; Material: Electrogalvanized carbon steel; MinWeight: 0.006 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: LBA460; ModelReference: n/a; Name: Nail; Nome famiglia: ROTHOB_Rothoblaas_Screw_LBA; NominalDiameter: 4 mm; NominalHeight: n/a; NominalLength: 60 mm; NominalWidth: n/a; ReplacementCost: n/a; Shape: Cylindrical; Size: 4 x 60 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Nail; Category: Pr_20_29_56_11 : Carbon steel nails
Pset_QuantityTakeOff - Reference: LBA460_4x60mm
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.000417969 m2; Volume: 6.22786e-07 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Screw_LBA; Famiglia e tipo: ROTHOB_Rothoblaas_Screw_LBA: LBA460_4x60mm; ID tipo: 806833; Tipo: LBA460_4x60mm
