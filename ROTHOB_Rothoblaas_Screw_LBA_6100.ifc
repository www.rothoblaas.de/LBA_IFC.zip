Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 573a5f2a-3657-4229-976a-7bcbb49b65ef, NumberOfSaves: 66], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Screw_LBA_6100.ifc
Time: 2025-10-31T11:41:20
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcMechanicalFastener: Collegamenti strutturali : ROTHOB_Rothoblaas_Screw_LBA : LBA6100_6x100mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Screw_LBA; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23.20.40.11.14.17; OmniClassTitle: Nails; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/screws/screws-carpentry/lba; Revision: 000; UniClass2015Code: Pr_20_29_56_11; UniClass2015Title: Carbon steel nails; UniClass2015Version: Products v1.39; Version: 001
Type - Vincoli - ModelNumberCode: 6100; Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized
Type - Quote - ExternalDiameter_de: 6.6 mm; HeadDiameter_dk: 12 mm; HeadThickness_t1: 2 mm; HoleDiameterOnSteelPlate_dvs: 7.00 ÷7.5 mm; InsertionLength_L: 98 mm; KnurledShanksLength_b: 85 mm; KnurledShanksRadius: 2.75 mm; NominalDiameter_d1: 6 mm; ShankLength_Ls: 10.15 mm; ThreadDiameter_d2: 5.5 mm; TipLength_Lt: 6.68 mm; UnderheadDiameter_d3: 7.8 mm; UnderheadLength_L1: 2.85 mm
Type - Dati identità - Descrizione: High bond nail; Nome del tipo: LBA6100_6x100mm; Numero OmniClass: 23.20.40.11.14.17; Produttore: info@rothoblaas.com; Titolo OmniClass: Nails
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_29_56_11 : Carbon steel nails; CECode: ETA-22/0002; CETitle: Rotho Blaas Connector Nails LBA; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: High bond nail; DurationUnit: Years; ExpectedLife: 50; Features: Adhesion nails with knurled shanks for timber constructions; Finish: Electrogalvanized; Grade: n/a; GTIN: 8033564765445; Manufacturer: info@rothoblaas.com; Material: Electrogalvanized carbon steel; MinWeight: 0.023 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: LBA6100; ModelReference: n/a; Name: Nail; Nome famiglia: ROTHOB_Rothoblaas_Screw_LBA; NominalDiameter: 6 mm; NominalHeight: n/a; NominalLength: 100 mm; NominalWidth: n/a; ReplacementCost: n/a; Shape: Cylindrical; Size: 6 x 100 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Nail; Category: Pr_20_29_56_11 : Carbon steel nails
Pset_QuantityTakeOff - Reference: LBA6100_6x100mm
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.00105731 m2; Volume: 0.00000252992 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Screw_LBA; Famiglia e tipo: ROTHOB_Rothoblaas_Screw_LBA: LBA6100_6x100mm; ID tipo: 806843; Tipo: LBA6100_6x100mm
